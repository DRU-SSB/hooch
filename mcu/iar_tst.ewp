# IAR project iar_tst.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\stm8_iar_perith\inc; E:\stm8_iar_perith\src; E:\stm8_iar_perith\inc\discovery; E:\stm8_iar_perith\src\discovery
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: iar_tst.srec
  ILINK.IlinkOutputFile: iar_tst.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
    ../stm8_iar_perith/inc/: stm8l15x.h
